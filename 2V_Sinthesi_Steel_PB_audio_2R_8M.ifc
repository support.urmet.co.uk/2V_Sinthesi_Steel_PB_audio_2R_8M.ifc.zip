Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-24T11:09:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Alternate UI 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 24 11:09:25 2021 * Host: URD0938 * Database: C:\Users\DNLMRCUD\AppData\Local\Temp\{061335F4-E3B7-4B12-A894-A4B6B2A9403E}\ifc * Database version: 5507 * Database creation date: Wed Mar 24 11:09:19 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 24 11:09:19 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 24 11:09:19 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm

# IfcBuildingElementProxy: 2V_Sinthesi_Steel_PB_audio_2R_8M, 2V_Sinthesi_Steel_PB_audio_2R_8M:2V_Sinthesi_Steel_PB_audio_2R_8M:147747
In: Livello 1
Type - Classification: 2V_Sinthesi_Steel_PB_audio_2R_8M (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 2V_Sinthesi_Steel_PB_audio_2R_8M
Pset_ManufacturerTypeInformation - Manufacturer: Urmet S.p.A. Urmet S.p.A.
